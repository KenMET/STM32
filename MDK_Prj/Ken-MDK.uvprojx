# Keil uVision project Ken-MDK.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Test +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\System\CMSIS\CoreSupport;..\System\CMSIS\DeviceSupport;..\System\CMSIS\StartUp;..\System\STM32F10x_StdLib\inc;..\System\Delay;..\Driver\Timer;..\Driver\Usart;..\User;..\KenOS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../System/CMSIS/CoreSupport/: core_cm3.c
  group DevSupport
    ../System/CMSIS/DeviceSupport/: system_stm32f10x.c
    ../System/Delay/: delay.c
  group StartUp
    ../System/CMSIS/StartUp/: startup_stm32f10x_md.s
  group StdLib
    ../System/STM32F10x_StdLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Driver
    ../Driver/Usart/: usart.c
    ../Driver/Timer/: timer.c
  group KenOS
    ../KenOS/: KenCore.c KenCoreASM.asm
  group User
    ../User/: main.c stm32f10x_it.c
